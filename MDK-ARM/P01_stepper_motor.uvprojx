# Keil uVision project P01_stepper_motor.uvprojx, settings and files
target P01_stepper_motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: P01_stepper_motor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -DNDEBUG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./common;./interface;./application;./interface/freeModbus;./interface/freeModbus/ascii;./interface/freeModbus/functions;./interface/freeModbus/include;./interface/freeModbus/port;./interface/freeModbus/rtu;./interface/key;./service;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source;../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ./common/: com_debug.c
  group interface
    ./interface/: Int_oled.c Int_oled.h Int_oledfont.h W24C02.c stepper.c
  group application
    ./application/: App_display.c App_key.c App_modbus_run.c
  group freeModbus
    ./interface/freeModbus/: mb.c port.c
  group freeModbus/rtu
    ./interface/freeModbus/rtu/: mbcrc.c mbrtu.c
  group freeModbus/functions
    ./interface/freeModbus/functions/: mbutils.c mbfuncother.c mbfuncinput.c mbfuncholding.c mbfuncdisc.c mbfuncdiag.c mbfunccoils.c
  group freeModbus/port
    ./interface/freeModbus/port/: portevent.c portserial.c porttimer.c
  group freeModbus/ascii
    ./interface/freeModbus/ascii/: mbascii.c
  group freeModbus/include
    ./interface/freeModbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group key
    ./interface/key/: key.c
  group service
    ./service/: app_state.c storage_svc.c
  group Middlewares\Third_Party\FreeRTOS\Source
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
